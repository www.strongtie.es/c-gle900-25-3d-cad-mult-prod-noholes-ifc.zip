Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-23T16:33:44
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 23 16:33:44 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{9F0DAED1-EE33-41D1-861D-49A12E03BC71}\ifc * Database version: 5507 * Database creation date: Mon Oct 23 16:33:44 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 23 16:33:44 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 23 16:33:44 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 3 - 210 Models\Remove Holes\RFA 3D\GLE900_230_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Graphics - Symbol at End 2 Default: yes; Symbol at End 1 Default: no; Line Pattern: -3000010; Line Weight: 1; Color: 0

# IfcBuildingElementProxy: GLE900_230_25, GLE900_230_25:GLE900_230_25:155910
In: Level 1
Material: Galvanised
Dimensions - Volume: 0.00722162 ft3
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE900/230/2.5
General - Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD; Density: 1.59; Reference: GLE900/230/2.5; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking
Identity Data - Name: GLE900/230/2.5; Model ID: 0057101673666581900519327589410759300403; OmniClass Title: Wood Connectors; ObjectType: GLE900/230/2.5; Description: Joist hanger; UniClass Number: Pr_20_29_31_44; UniClass Title: Joist hangers; Manufacturer: Simpson Strong-Tie; URL: www.strongtie.eu; Product Type: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model: GLE900/230/2.5; Copyright: ©Simpson Strong-Tie; OmniClass Number: 23.20.40.11.24.14
Materials and Finishes - Product Material: Galvanised
