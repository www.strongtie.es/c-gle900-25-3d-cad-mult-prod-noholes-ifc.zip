Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-23T16:33:35
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 23 16:33:35 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{B1AE71FC-DF16-4550-95BD-76BFFFFCA69C}\ifc * Database version: 5507 * Database creation date: Mon Oct 23 16:33:35 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 23 16:33:35 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 23 16:33:35 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 3 - 210 Models\Remove Holes\RFA 3D\GLE900_196_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 1 Default: no; Line Weight: 1; Line Pattern: -3000010; Symbol at End 2 Default: yes; Color: 0

# IfcBuildingElementProxy: GLE900_196_25, GLE900_196_25:GLE900_196_25:145234
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.00722162 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE900/196/2.5
Identity Data - Model ID: 0057101673666581900519327589410759300403; URL: www.strongtie.eu; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; OmniClass Number: 23.20.40.11.24.14; UniClass Title: Joist hangers; Provide Feedback: mailto:EUdrawings@strongtie.com; Manufacturer: Simpson Strong-Tie; ObjectType: GLE900/196/2.5; Model: GLE900/196/2.5; Description: Joist hanger; Copyright: ©Simpson Strong-Tie; Product Type: Joist hanger; Name: GLE900/196/2.5; UniClass Number: Pr_20_29_31_44; OmniClass Title: Wood Connectors
General - Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Reference: GLE900/196/2.5; Density: 1.59; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking
Materials and Finishes - Product Material: Galvanised
