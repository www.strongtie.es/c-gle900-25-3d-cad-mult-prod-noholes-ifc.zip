Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-23T16:32:52
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 23 16:32:52 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{F9146451-B1D2-4097-A42A-B92D1A9619D1}\ifc * Database version: 5507 * Database creation date: Mon Oct 23 16:32:52 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 23 16:32:52 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 23 16:32:52 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 3 - 210 Models\Remove Holes\RFA 3D\GLE900_52_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Building Story: yes; Structural: no
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 1 Default: no; Symbol at End 2 Default: yes; Color: 0; Line Pattern: -3000010; Line Weight: 1

# IfcBuildingElementProxy: GLE900_52_25, GLE900_52_25:GLE900_52_25:100018
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00723928 ft3
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE900/52/2.5
Identity Data - Copyright: ©Simpson Strong-Tie; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; UniClass Title: Joist hangers; Manufacturer: Simpson Strong-Tie; Model ID: 0338054267256364225183278042239561766123; OmniClass Title: Wood Connectors; Product Type: Joist hanger; Name: GLE900/52/2.5; ObjectType: GLE900/52/2.5; UniClass Number: Pr_20_29_31_44; Model: GLE900/52/2.5; Description: Joist hanger; OmniClass Number: 23.20.40.11.24.14; Provide Feedback: mailto:EUdrawings@strongtie.com; URL: www.strongtie.eu
General - ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Density: 1.59; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Reference: GLE900/52/2.5; EPD: https://www.strongtie.eu/eu-EU/EPD
Materials and Finishes - Product Material: Galvanised
