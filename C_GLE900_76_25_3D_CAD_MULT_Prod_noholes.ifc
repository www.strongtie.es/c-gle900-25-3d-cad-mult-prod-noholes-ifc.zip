Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-23T16:32:59
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 23 16:32:59 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{FB1DDE9A-2F75-4988-A654-78480686E554}\ifc * Database version: 5507 * Database creation date: Mon Oct 23 16:32:59 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 23 16:32:59 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 23 16:32:59 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 3 - 210 Models\Remove Holes\RFA 3D\GLE900_76_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: -3000010; Symbol at End 2 Default: yes; Line Weight: 1; Symbol at End 1 Default: no

# IfcBuildingElementProxy: GLE900_76_25, GLE900_76_25:GLE900_76_25:107554
In: Level 1
Material: Galvanised
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00723928 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE900/76/2.5
Identity Data - ObjectType: GLE900/76/2.5; Copyright: ©Simpson Strong-Tie; Product Type: Joist hanger; OmniClass Title: Wood Connectors; Model ID: 0338054267256364225183278042239561766123; Provide Feedback: mailto:EUdrawings@strongtie.com; URL: www.strongtie.eu; Name: GLE900/76/2.5; OmniClass Number: 23.20.40.11.24.14; UniClass Number: Pr_20_29_31_44; Model: GLE900/76/2.5; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Description: Joist hanger; UniClass Title: Joist hangers; Manufacturer: Simpson Strong-Tie
Materials and Finishes - Product Material: Galvanised
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Reference: GLE900/76/2.5; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Density: 1.59; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking
