Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-23T16:33:36
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 23 16:33:36 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{9080618A-11EF-44F8-9DC7-E34832CB1A6D}\ifc * Database version: 5507 * Database creation date: Mon Oct 23 16:33:36 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 23 16:33:36 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 23 16:33:36 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 3 - 210 Models\Remove Holes\RFA 3D\GLE900_202_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Graphics - Line Weight: 1; Symbol at End 1 Default: no; Color: 0; Line Pattern: -3000010; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: GLE900_202_25, GLE900_202_25:GLE900_202_25:147118
In: Level 1
Material: Galvanised
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.00722162 ft3
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE900/202/2.5
Identity Data - Description: Joist hanger; Manufacturer: Simpson Strong-Tie; Model ID: 0057101673666581900519327589410759300403; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; OmniClass Number: 23.20.40.11.24.14; Product Type: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com; OmniClass Title: Wood Connectors; ObjectType: GLE900/202/2.5; UniClass Title: Joist hangers; Copyright: ©Simpson Strong-Tie; URL: www.strongtie.eu; UniClass Number: Pr_20_29_31_44; Model: GLE900/202/2.5; Name: GLE900/202/2.5
General - Density: 1.59; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; EPD: https://www.strongtie.eu/eu-EU/EPD; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Reference: GLE900/202/2.5
Materials and Finishes - Product Material: Galvanised
